# Keil uVision project f072cbt6.uvprojx, settings and files
target f072cbt6 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072CB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: f072cbt6
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F072xB,EMPL_TARGET_STM32F0,MPU9250
  c misc: --C99
  c include: ../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;..\Drivers\Hardware\decadriver;..\Drivers\Hardware\NRF24l01;..\Drivers\Hardware\Platform_deca;..\Drivers\Hardware\USAMRT;..\Drivers\Hardware\USART;..\MDK-ARM;..\Src;..\Inc;../Inc;..\Drivers\Hardware\I2C;..\Drivers\Hardware\MPL;..\Drivers\Hardware\MPL\mpl;..\Drivers\Hardware\MPL\mllite;..\Drivers\Hardware\MPL\eMPL-hal;..\Drivers\Hardware\MPL\driver\include;..\Drivers\Hardware\MPL\driver\eMPL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_i2c.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_cortex.c stm32f0xx_hal_spi.c stm32f0xx_hal_spi_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_iwdg.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
  group Application/MDK-ARM
    ./: startup_stm32f072xb.s
  group Application/User
    ../Src/: stm32f0xx_it.c stm32f0xx_hal_msp.c main.c delay.c Testing.c
  group Hardwares
    ../Drivers/Hardware/Platform_deca/: deca_callback.c deca_mutex.c deca_sleep.c deca_spi.c dw1000.c
    ../Drivers/Hardware/decadriver/: deca_device.c deca_params_init.c
    ../Drivers/Hardware/NRF24l01/: rf24l01.c
  group USMART
    ../Drivers/Hardware/USAMRT/: usmart.c usmart_config.c usmart_str.c
  group MPU9250
    ../Drivers/Hardware/MPL/: mpu9250.c MadgwickAHRS.c
    ../Drivers/Hardware/MPL/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../Drivers/Hardware/I2C/: I2C.c
software components: CMSIS:CORE 4.1.0
