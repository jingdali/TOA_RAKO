# Keil uVision project protest.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F072RB STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: protest +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F0XX_HD,USE_STDPERIPH_DRIVER
  c include: .\FWlib\inc;.\CORE;.\SYSTEM;.\USER;.\USER\Delay;.\USER\Usmart;.\HARDWARE\SPI;.\HARDWARE\EXTI;.\HARDWARE\decadriver;.\HARDWARE\Platform_deca;.\HARDWARE\USART;.\HARDWARE\LED;.\HARDWARE\NRF24L01;.\HARDWARE\WDG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group HARDWARE
    ./HARDWARE/USART/: usart_v1.c
    ./HARDWARE/SPI/: spi_v1.c
    ./HARDWARE/EXTI/: EXTI_v1.c
    ./HARDWARE/Platform_deca/: deca_sleep.c deca_mutex.c deca_spi.c deca_callback.c Deca_user_api.c
    ./HARDWARE/LED/: LED.c
    ./HARDWARE/NRF24L01/: rf24l01.c
  group USER
    ./USER/: main.c test_fun.c sys.h list.h
    ./USER/Delay/: delay.c
    ./HARDWARE/WDG/: wdg.c
  group FWlib
    ./FWlib/src/: stm32f0xx_exti.c stm32f0xx_gpio.c stm32f0xx_misc.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c stm32f0xx_flash.c stm32f0xx_pwr.c stm32f0xx_dma.c stm32f0xx_crc.c stm32f0xx_iwdg.c
  group SYSTEM
    ./SYSTEM/: stm32f0xx_it.c system_stm32f0xx.c startup_stm32f072.s stm32f0xx_conf.h
  group USMART
    ./USER/Usmart/: usmart.c usmart_config.c usmart_str.c
  group Decadriver
    ./HARDWARE/decadriver/: deca_device.c deca_params_init.c deca_device_api.h deca_param_types.h deca_regs.h deca_types.h
